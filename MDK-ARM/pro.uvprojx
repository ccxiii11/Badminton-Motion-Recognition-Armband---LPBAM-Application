# Keil uVision project pro.uvprojx, settings and files
target pro (6240000::V6.24::ARMCLANG)
  device: STM32U545RETx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: pro +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U545xx
  c include: ../Core/Inc;../LPBAM/DA;../Utilities/lpbam;../Utilities/lpbam/STM32U5;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../HARD;../BLUE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x28000000 size 0x4000
  scatter file: pro\pro.sct
  group Application/MDK-ARM
    ./: startup_stm32u545xx.s
  group Application/User/Core
    ../Core/Src/: i2c_cpu.c app.c main.c gpio.c icache.c lpbam.c lpbamqueue.c lpdma.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Application/User/LPBAM/DA
    ../LPBAM/DA/: lpbam_da_device_config.c lpbam_da_config.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_ramcfg.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Utilities
    ../Utilities/lpbam/: stm32_adv_lpbam_common.c stm32_lpbam_common.c stm32_adv_lpbam_i2c.c stm32_lpbam_i2c.c stm32_lpbam_lptim.c
    ../Utilities/lpbam/STM32U5/: stm32_ll_lpbam.c
  group HARD
    ../HARD/: lpbam_user.c lsm.c mlc_load.c model_infer.c score_voice.c syn6288e.c libneai.a
software components: CMSIS:CORE 5.6.0
